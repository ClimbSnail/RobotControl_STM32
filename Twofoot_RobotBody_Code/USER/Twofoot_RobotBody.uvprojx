# Keil uVision project Twofoot_RobotBody.uvprojx, settings and files
target Twofoot_RobotBody (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Twofoot_RobotBody +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\PWM;..\HARDWARE\OLED;..\HARDWARE;..\HARDWARE\USART;..\HARDWARE\GPS;..\HARDWARE\XFS5152V2;..\HARDWARE\DMA;..\HARDWARE\uart5
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/: ADC.c action.c allActionArr.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/USART/: MY_USART3.c
    ../HARDWARE/GPS/: gps.c
    ../HARDWARE/DMA/: DMA.C
    ../HARDWARE/uart5/: uart5.c
    ../HARDWARE/XFS5152V2/: XFS5152V2.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c
  group README
    ../: README.TXT
